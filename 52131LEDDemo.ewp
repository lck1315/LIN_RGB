# IAR project 52131LEDDemo.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430_EL_M52199B EL_M52199B
  General.GStackSize2: 360
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: STDIO_SCI_HARD
  ICC430.newCCIncludePaths: LINDrv\; API\inc\; $PROJ_DIR$
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkEL_M52199B.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430_EL_M52199A EL_M52199A
  General.GStackSize2: 80
  ICC430.newCCIncludePaths: API\inc\; $PROJ_DIR$
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkEL_M52199A.xcl
  group (top)
    ./: main.c mod_adc.c mod_gpio.c mod_hvctrl.c mod_pwm.c mod_sci.c mod_swt.c mod_sys.c stdio_read.c stdio_write.c version.h
  group API
    api/: adc_ctrl.c cctimer.c divider.c gpio.c h430_mul.c hv_ctrl.c pwm.c sci.c swtimer.c sys_state.c utils.c vic.c wdog.c
